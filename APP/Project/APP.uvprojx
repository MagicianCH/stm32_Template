# Keil uVision project APP.uvprojx, settings and files
target APP (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APP
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Library\USER;..\..\Library\CORE;..\..\Library\MALLOC;..\..\Library\USMART;..\..\Library\SYSTEM\delay;..\..\Library\SYSTEM\sys;..\..\Library\SYSTEM\usart;..\..\Library\FWLIB\STM32F10x_FWLib\inc;..\..\Library\UCOSIII\uC-CPU;..\..\Library\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\..\Library\UCOSIII\uC-LIB;..\..\Library\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\Library\UCOSIII\uCOS-III;..\..\Library\UCOSIII\uCOS-III\Source;..\..\Library\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\Library\UCOSIII\UCOS_BSP;..\..\Library\UCOSIII\uCOS_CONFIG;..\User;..\Hardware\LED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../User/: main.c
  group HARDWARE
    ../Hardware/LED/: led.c
  group LIB
    ../../Library/OBJ/: Library.lib
